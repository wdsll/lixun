# Keil uVision project W5500_Client.uvprojx, settings and files
target W5500 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: W5500_Client
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__FPU_PRESENT
  c include: ..\USER;..\GD32_SYSTEM\Firmware\CMSIS\GD\GD32F30x\Include;..\GD32_SYSTEM\Firmware\GD32F30x_standard_peripheral\Include;..\HARDWARE\int;..\GD32_SYSTEM\Firmware\CMSIS;..\USER_APP\int
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: bsp_SysTicks.c gd32f30x_it.c main.c
  group USER_APP
    ../USER_APP/src/: W5500.c
  group CMSIS
    ../GD32_SYSTEM/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F0x_Peripherals
    ../GD32_SYSTEM/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../GD32_SYSTEM/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group HARDWARE
    ../HARDWARE/src/: uart.c spi.c timer.c
